SRC_URI += "file://user_MZ7010_FMCCC.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
